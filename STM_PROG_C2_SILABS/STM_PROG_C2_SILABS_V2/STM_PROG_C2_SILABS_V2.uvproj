# Keil uVision project STM_PROG_C2_SILABS_V2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM_PROG_C2_SILABS_V2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, CoCOS_EN=0, __CC_ARM
  c misc: --c99
  c include: .\SRC;.\SRC\LIB;.\SRC\LIB\inc;.\SRC\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f10x_md_vl.s
  group SRC
    ./SRC/: progall.c main.c STM32_Init.c
  group SRC_MAX_SPEED
    ./SRC/: main_loop.c HD_PARS.c C2_Interface.c C2_Interface_CFG.c rb_fifo.c rb_util.c cortex_rb_dwt.c cortex_rb_sys.c core_UID.c
  group LIB
    ./SRC/LIB/: cortexm3_macro.s stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./SRC/HARDWARE/: hardware.c
  group HARDWARE_MAX_SPEED
    ./SRC/HARDWARE/: hdports.c hdtimers.c interface.c hdtmrpwm.c hdspi.c hdadc.c
